Properties of the parts of a building model (IFC4)

# File
Description: Tauchhülse, 100 mm, Ms vernickelt, Durchmesser InnenxAußen 14,8 x 17 mm, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: KA979901, Tauchhülse, 100 mm, Ms vernickelt, Durchmesser InnenxAußen 14,8 x 17 mm
In: Raum
Description: Tauchhülse für Einbau in flüssige Medien, 100 mm, Ms vernickelt, Durchmesser Innen x Außen 14,8 x 17mm; Classification: EC010502 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: KA979901; ModelLabel: THK-2-100x17; GlobalTradeItemNumber: 4050528075420; ProductURL: https://alre.de/produkt_KA979901
Pset_Specification - NominalLength: 0.113 m; NominalWidth: 0.022 m; NominalDepth: 0.022 m; NetWeight: 0.075
Pset_ALRE_ETIM_Properties - Außendurchmesser: 17; Innendurchmesser: 14.8; Druckstufe Artikel: PN 20; Material Tauchrohr: Messing; Einstecklänge: 100; Nenndurchmesser Anschluss: 1/2 Zoll (15); ETIM-Klasse: EC010502; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-KA979901.pdf
